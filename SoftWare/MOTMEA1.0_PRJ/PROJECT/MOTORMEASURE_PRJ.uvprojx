# Keil uVision project MOTORMEASURE_PRJ.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MOTORMEASURE_PRJ +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\FWLIB;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\HARDWARE;..\USER;..\FatFs;..\MALLOC;..\Page;..\HARDWARE\GPIO
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c sys_manager.c user_control.c message_send.c message_analysis.c data_init.c sdcard_control.c test.c
  group FWLIB
    ../FWLIB/: stm32f10x_it.c stm32f10x_sdio.c
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_tim.c
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/: LED_buzzer.c usart.c dma.c sdio.c assembler.c GPIO_Control.c
  group STARTUP
    ../FWLIB/: startup_stm32f10x_md.s
  group FATFS
    ../FatFs/: cc936.c diskio.c ff.c exfuns.c
  group MALLOC
    ../MALLOC/: malloc.c
  group PAGE
    ../Page/: config_page_control.c adjust_page_control.c debug_page_control.c test_page_control.c password_page_control.c begin_page_control.c
  group GPIO
    ../HARDWARE/GPIO/: CUR.c PWM.c FG.c Relay.c Reserved.c ReservedTest.c testState.c
